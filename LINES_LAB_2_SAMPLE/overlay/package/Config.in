## package/puzzle/Config.in
```kconfig
config BR2_PACKAGE_PUZZLE
	bool "puzzle"
	select BR2_PACKAGE_LIBGPIOD
	help
		An LED game.
```
